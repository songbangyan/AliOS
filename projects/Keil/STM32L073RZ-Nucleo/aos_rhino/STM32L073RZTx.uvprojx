# Keil uVision project STM32L073RZTx.uvprojx, settings and files
target STM32L073RZTx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L073RBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32L073RZTx +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L073xx,AOS_KV
  c misc: --C99 -DSYSINFO_OS_VERSION=\"APP-1.0.0\" -DSYSINFO_PRODUCT_MODEL=\"ALI_AOS_STM32L073RZTx\" -DSYSINFO_DEVICE_NAME=\"STM32L073RZTx\" -DSYSINFO_KERNEL_VERSION=\"AOS-R-1.2.1\" -DSYSINFO_APP_VERSION=\"APP-1.0.0\" -DSTDIO_UART=0 -DCONFIG_NO_TCPIP -DRHINO_CONFIG_TICK_TASK=0 -DCONFIG_AOS_KV_MULTIPTN_MODE -DCONFIG_AOS_KV_PTN=6 -DCONFIG_AOS_KV_SECOND_PTN=7 -DCONFIG_AOS_KV_PTN_SIZE=4096 -DCONFIG_AOS_KV_BUFFER_SIZE=8192 -D__BSD_VISIBLE -DRHINO_CONFIG_TICK_TASK=0
  c include: ..\..\..\..\include;..\..\..\..\kernel\rhino\core\include;..\..\..\..\platform\arch\arm\armv6m\armcc\m0;..\..\..\..\platform\mcu\stm32l0xx\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\platform\mcu\stm32l0xx\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\mcu\stm32l0xx\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\platform\mcu\stm32l0xx\Drivers\CMSIS\Include;..\..\..\..\platform\mcu\stm32l0xx\src\STM32L073RZ-Nucleo\aos_rhino;..\..\..\..\include\hal;..\..\..\..\kernel\modules\fs\kv\include;..\..\..\..\kernel\vcall\aos;..\..\..\..\utility\libc\compilers\armlibc;..\..\..\..\kernel\vfs\include;..\..\..\..\test\yunit\include;..\..\..\..\test\testcase\include;..\..\..\..\test\testcase\certificate_test\cutest
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group platform\mcu\stm32l0xx\Drivers\STM32l0xx_HAL_Driver\Src
    ../../../../platform/mcu/stm32l0xx/Drivers/STM32l0xx_HAL_Driver/Src/: stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_tim.c stm32l0xx_hal_rcc.c stm32l0xx_hal_uart.c stm32l0xx_hal_cortex.c stm32l0xx_hal_i2c_ex.c
  group platform\mcu\stm32l0xx\src\STM32L073RZ-Nucleo
    ../../../../platform/mcu/stm32l0xx/src/STM32L073RZ-Nucleo/aos_rhino/: soc_init.c stm32l0xx_hal_msp.c stm32l0xx_it.c system_stm32l0xx.c
    ../../../../platform/mcu/stm32l0xx/src/STM32L073RZ-Nucleo/: startup_stm32l073xx_keil.s
  group platform\mcu\stm32l0xx\src\STM32L073RZ-Nucleo\hal
    ../../../../platform/mcu/stm32l0xx/src/STM32L073RZ-Nucleo/hal/: flash_port.c
  group kernel\rhino\core
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group platform\mcu\stm32l0xx\aos
    ../../../../platform/mcu/stm32l0xx/aos/: soc_impl.c
  group platform\arch\arm\armv6m\armcc\m0
    ../../../../platform/arch/arm/armv6m/armcc/m0/: port_c.c port_s.S
  group utility\libc\compilers\armlibc
    ../../../../utility/libc/compilers/armlibc/: armcc_libc.c
  group board\STM32L073RZ-Nucleo
    ../../../../board/stm32l073rz-nucleo/: board.c
  group kernel\modules\fs\kv
    ../../../../kernel/modules/fs/kv/: kvmgr.c
  group kernel\vcall
    ../../../../platform/mcu/stm32l0xx/src/STM32L073RZ-Nucleo/aos_rhino/: aos_rhino_kv.c
  group example
    ../../../../example/rhinorun/: rhinorun.c
  group kernel\vfs
    ../../../../kernel/vfs/: vfs.c vfs_file.c vfs_inode.c
  group test
    ../../../../test/testcase/certificate_test/: rhino_test.c
    ../../../../test/testcase/certificate_test/cutest/: cut.c
